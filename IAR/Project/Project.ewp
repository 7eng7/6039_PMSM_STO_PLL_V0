# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ET6039 ETMCU ET6039
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..\..\Source\BSP; ..\..\Source\DEBUG
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 3
  group DEBUG
    ../../Source/DEBUG/: debug.c usart.c
  group DRIVER
    ../../Source/BSP/: adc.c bldc.c bldc_tim.c control.c key.c led.c pid.c
  group USER
    ../../Source/User/: main.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/CMSIS.DSP Source
    ${CMSIS_PACK_PATH_ARM#CMSIS-DSP#1.16.2}$/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
    ${CMSIS_PACK_PATH_ARM#CMSIS-DSP#1.16.2}$/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
    ${CMSIS_PACK_PATH_ARM#CMSIS-DSP#1.16.2}$/Source/CommonTables/: CommonTables.c CommonTablesF16.c
    ${CMSIS_PACK_PATH_ARM#CMSIS-DSP#1.16.2}$/Source/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
    ${CMSIS_PACK_PATH_ARM#CMSIS-DSP#1.16.2}$/Source/ControllerFunctions/: ControllerFunctions.c
    ${CMSIS_PACK_PATH_ARM#CMSIS-DSP#1.16.2}$/Source/DistanceFunctions/: DistanceFunctions.c DistanceFunctionsF16.c
    ${CMSIS_PACK_PATH_ARM#CMSIS-DSP#1.16.2}$/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
    ${CMSIS_PACK_PATH_ARM#CMSIS-DSP#1.16.2}$/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
    ${CMSIS_PACK_PATH_ARM#CMSIS-DSP#1.16.2}$/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
    ${CMSIS_PACK_PATH_ARM#CMSIS-DSP#1.16.2}$/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
    ${CMSIS_PACK_PATH_ARM#CMSIS-DSP#1.16.2}$/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ${CMSIS_PACK_PATH_ARM#CMSIS-DSP#1.16.2}$/Source/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
    ${CMSIS_PACK_PATH_ARM#CMSIS-DSP#1.16.2}$/Source/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
    ${CMSIS_PACK_PATH_ARM#CMSIS-DSP#1.16.2}$/Source/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
    ${CMSIS_PACK_PATH_ARM#CMSIS-DSP#1.16.2}$/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
    ${CMSIS_PACK_PATH_ARM#CMSIS-DSP#1.16.2}$/Source/WindowFunctions/: WindowFunctions.c
  group CMSIS-Pack/Device.Drivers XBAR
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_xbar.c
  group CMSIS-Pack/Device.Drivers WDG
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_wdg.c
  group CMSIS-Pack/Device.Drivers WAG
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_wag.c
  group CMSIS-Pack/Device.Drivers UART
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_uart.c
  group CMSIS-Pack/Device.Drivers SYSCTRL
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_sysctrl.c
  group CMSIS-Pack/Device.Drivers STIMER
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_stimer.c
  group CMSIS-Pack/Device.Drivers SRPWM
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_srpwm.c
  group CMSIS-Pack/Device.Drivers SPI
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_spi.c
  group CMSIS-Pack/Device.Drivers SDFM
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_sdfm.c
  group CMSIS-Pack/Device.Drivers INTERRUPT
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_interrupt.c
  group CMSIS-Pack/Device.Drivers I2C
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_i2c.c
  group CMSIS-Pack/Device.Drivers GPIO
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_gpio.c
  group CMSIS-Pack/Device.Drivers FMAC
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_fmac.c
  group CMSIS-Pack/Device.Drivers ETIMER
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_etimer.c
  group CMSIS-Pack/Device.Drivers EQEP
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_eqep.c
  group CMSIS-Pack/Device.Drivers EFC
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_flash.c
  group CMSIS-Pack/Device.Drivers DMA
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_ahbdma.c
  group CMSIS-Pack/Device.Drivers DAC
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_dac.c
  group CMSIS-Pack/Device.Drivers CRG
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_crg.c
  group CMSIS-Pack/Device.Drivers CRC
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_crc.c
  group CMSIS-Pack/Device.Drivers CORTEX
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_cortex.c
  group CMSIS-Pack/Device.Drivers CORDIC
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_cordic.c
  group CMSIS-Pack/Device.Drivers CAN
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_can.c
  group CMSIS-Pack/Device.Drivers AES
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_aes.c
  group CMSIS-Pack/Device.Drivers ADC
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_adc.c
  group CMSIS-Pack/Device.Drivers ACMP
    ${CMSIS_PACK_PATH_ETMCU#ET6039_DFP#0.2.4}$/ET6x_Driver/Src/: et6x_acmp.c
  group CMSIS-Pack/Device Startup
    RTE/Device/ET6039/: startup_et6039_iar.s system_et6x.c
