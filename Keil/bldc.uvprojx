# Keil uVision project bldc.uvprojx, settings and files
target FLASH (6240000::V6.24::ARMCLANG)
  device: ET6039 ETMCU
  pack: ETMCU.ET6039_DFP.0.2.4
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20400000,0x18000) IROM(0x08000000,0x80000) IROM2(0x00000000,0x8000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: bldc +hex
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FLASH_CODE,USE_FULL_ASSERT
  c misc: -gdwarf-5
  c include: ..\Application\Inc;..\MCSDK_v5.4.4-Full\MotorControl\MCSDK\MCLib\Any\Inc;..\MCSDK_v5.4.4-Full\MotorControl\MCSDK\MCLib\F4xx\Inc;..\MCSDK_v5.4.4-Full\MotorControl\MCSDK\UILibrary\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20400000 size 0x18000
  group Application
    ../Application/Src/: dac_ui.c main.c mc_api.c mc_config.c mc_interface.c mc_math.c mc_parameters.c mc_tasks.c motor_control_protocol.c motorcontrol.c regular_conversion_manager.c ui_task.c user_interface.c key.c init_config.c mc_it.c
  group Middlewares/MotorControl
    ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c motor_power_measurement.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c pwm_common.c pwm_curr_fdbk.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c revup_ctrl.c speed_pos_fdbk.c speed_torq_ctrl.c state_machine.c virtual_speed_sensor.c sto_pll_speed_pos_fdbk.c
    ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/MCLib/F4xx/Src/: r3_2_f4xx_pwm_curr_fdbk.c
    ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/UILibrary/Src/: ui_irq_handler.c usart_frame_communication_protocol.c dac_common_ui.c frame_communication_protocol.c
software components: CMSIS:CORE 6.1.1, Device:Drivers:ACMP 0.2.3, Device:Drivers:ADC 0.2.3, Device:Drivers:AES 0.2.3, Device:Drivers:CORTEX 0.2.3, Device:Drivers:CRC 0.2.3, Device:Drivers:CRG 0.2.3, Device:Drivers:DAC 0.2.3, Device:Drivers:DMA 0.2.3, Device:Drivers:EFC 0.2.3, Device:Drivers:EQEP 0.2.3, Device:Drivers:ETIMER 0.2.3, Device:Drivers:GPIO 0.2.3, Device:Drivers:I2C 0.2.3, Device:Drivers:INTERRUPT 0.2.3, Device:Drivers:SPI 0.2.3, Device:Drivers:SRPWM 0.2.3, Device:Drivers:STIMER 0.2.3, Device:Drivers:SYSCTRL 0.2.3, Device:Drivers:UART 0.2.3, Device:Drivers:WDG 0.2.3, Device:Drivers:XBAR 0.2.3, Device:Startup 0.2.3
